##
## LEF for PtnCells ;
## created by Encounter v10.12-e077_1 on Wed Mar 16 14:29:29 2011
##

VERSION 5.6 ;

BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 2000 ;
END UNITS

MACRO CDK_R512x16
  CLASS BLOCK ;
  SIZE 98.6350 BY 95.7600 ;
  FOREIGN CDK_R512x16 0.0000 0.0000 ;
  ORIGIN 0 0 ;
  SYMMETRY X Y R90 ;
  PIN ADDRESS[8]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ADDRESS[8]
  PIN ADDRESS[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ADDRESS[7]
  PIN ADDRESS[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ADDRESS[6]
  PIN ADDRESS[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ADDRESS[5]
  PIN ADDRESS[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ADDRESS[4]
  PIN ADDRESS[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ADDRESS[3]
  PIN ADDRESS[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ADDRESS[2]
  PIN ADDRESS[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ADDRESS[1]
  PIN ADDRESS[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ADDRESS[0]
  PIN ROM_OUT[15]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ROM_OUT[15]
  PIN ROM_OUT[14]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ROM_OUT[14]
  PIN ROM_OUT[13]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ROM_OUT[13]
  PIN ROM_OUT[12]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ROM_OUT[12]
  PIN ROM_OUT[11]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ROM_OUT[11]
  PIN ROM_OUT[10]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ROM_OUT[10]
  PIN ROM_OUT[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ROM_OUT[9]
  PIN ROM_OUT[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ROM_OUT[8]
  PIN ROM_OUT[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ROM_OUT[7]
  PIN ROM_OUT[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ROM_OUT[6]
  PIN ROM_OUT[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ROM_OUT[5]
  PIN ROM_OUT[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ROM_OUT[4]
  PIN ROM_OUT[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ROM_OUT[3]
  PIN ROM_OUT[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ROM_OUT[2]
  PIN ROM_OUT[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ROM_OUT[1]
  PIN ROM_OUT[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ROM_OUT[0]
  PIN CLOCK
    DIRECTION INPUT ;
    USE SIGNAL ;
  END CLOCK
  PIN ENABLE
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ENABLE
  OBS
    LAYER M1 ;
      RECT 0.0000 0.0000 98.6350 95.7600 ;
    LAYER M2 ;
      RECT 0.0000 0.0000 98.6350 95.7600 ;
    LAYER M3 ;
      RECT 0.0000 0.0000 98.6350 95.7600 ;
    LAYER M4 ;
      RECT 0.0000 0.0000 98.6350 95.7600 ;
    LAYER M5 ;
      RECT 0.0000 0.0000 98.6350 95.7600 ;
    LAYER M6 ;
      RECT 0.0000 0.0000 98.6350 95.7600 ;
    LAYER M7 ;
      RECT 0.0000 0.0000 98.6350 95.7600 ;
    LAYER M8 ;
      RECT 0.0000 0.0000 98.6350 95.7600 ;
    LAYER M9 ;
      RECT 0.0000 0.0000 98.6350 95.7600 ;
    LAYER M10 ;
      RECT 0.0000 0.0000 98.6350 95.7600 ;
    LAYER M11 ;
      RECT 0.0000 0.0000 98.6350 95.7600 ;
  END
END CDK_R512x16

END LIBRARY
