##
## LEF for PtnCells ;
## created by Encounter v10.12-e077_1 on Wed Mar 16 14:30:05 2011
##

VERSION 5.6 ;

BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 2000 ;
END UNITS

MACRO CDK_S128x16
  CLASS BLOCK ;
  SIZE 248.0400 BY 246.2400 ;
  FOREIGN CDK_S128x16 0.0000 0.0000 ;
  ORIGIN 0 0 ;
  SYMMETRY X Y R90 ;
  PIN ADDRESS[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ADDRESS[7]
  PIN ADDRESS[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ADDRESS[6]
  PIN ADDRESS[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ADDRESS[5]
  PIN ADDRESS[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ADDRESS[4]
  PIN ADDRESS[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ADDRESS[3]
  PIN ADDRESS[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ADDRESS[2]
  PIN ADDRESS[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ADDRESS[1]
  PIN ADDRESS[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ADDRESS[0]
  PIN DATA_IN[15]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END DATA_IN[15]
  PIN DATA_IN[14]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END DATA_IN[14]
  PIN DATA_IN[13]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END DATA_IN[13]
  PIN DATA_IN[12]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END DATA_IN[12]
  PIN DATA_IN[11]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END DATA_IN[11]
  PIN DATA_IN[10]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END DATA_IN[10]
  PIN DATA_IN[9]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END DATA_IN[9]
  PIN DATA_IN[8]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END DATA_IN[8]
  PIN DATA_IN[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END DATA_IN[7]
  PIN DATA_IN[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END DATA_IN[6]
  PIN DATA_IN[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END DATA_IN[5]
  PIN DATA_IN[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END DATA_IN[4]
  PIN DATA_IN[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END DATA_IN[3]
  PIN DATA_IN[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END DATA_IN[2]
  PIN DATA_IN[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END DATA_IN[1]
  PIN DATA_IN[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END DATA_IN[0]
  PIN DATA_OUT[15]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END DATA_OUT[15]
  PIN DATA_OUT[14]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END DATA_OUT[14]
  PIN DATA_OUT[13]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END DATA_OUT[13]
  PIN DATA_OUT[12]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END DATA_OUT[12]
  PIN DATA_OUT[11]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END DATA_OUT[11]
  PIN DATA_OUT[10]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END DATA_OUT[10]
  PIN DATA_OUT[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END DATA_OUT[9]
  PIN DATA_OUT[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END DATA_OUT[8]
  PIN DATA_OUT[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END DATA_OUT[7]
  PIN DATA_OUT[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END DATA_OUT[6]
  PIN DATA_OUT[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END DATA_OUT[5]
  PIN DATA_OUT[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END DATA_OUT[4]
  PIN DATA_OUT[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END DATA_OUT[3]
  PIN DATA_OUT[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END DATA_OUT[2]
  PIN DATA_OUT[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END DATA_OUT[1]
  PIN DATA_OUT[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END DATA_OUT[0]
  PIN ENABLE
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ENABLE
  PIN WR_ENABLE
    DIRECTION INPUT ;
    USE SIGNAL ;
  END WR_ENABLE
  PIN CLOCK
    DIRECTION INPUT ;
    USE SIGNAL ;
  END CLOCK
  OBS
    LAYER M1 ;
      RECT 0.0000 0.0000 248.0400 246.2400 ;
    LAYER M2 ;
      RECT 0.0000 0.0000 248.0400 246.2400 ;
    LAYER M3 ;
      RECT 0.0000 0.0000 248.0400 246.2400 ;
    LAYER M4 ;
      RECT 0.0000 0.0000 248.0400 246.2400 ;
    LAYER M5 ;
      RECT 0.0000 0.0000 248.0400 246.2400 ;
    LAYER M6 ;
      RECT 0.0000 0.0000 248.0400 246.2400 ;
    LAYER M7 ;
      RECT 0.0000 0.0000 248.0400 246.2400 ;
    LAYER M8 ;
      RECT 0.0000 0.0000 248.0400 246.2400 ;
    LAYER M9 ;
      RECT 0.0000 0.0000 248.0400 246.2400 ;
    LAYER M10 ;
      RECT 0.0000 0.0000 248.0400 246.2400 ;
    LAYER M11 ;
      RECT 0.0000 0.0000 248.0400 246.2400 ;
  END
END CDK_S128x16

END LIBRARY
